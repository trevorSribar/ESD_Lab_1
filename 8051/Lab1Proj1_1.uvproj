# Keil uVision project Lab1Proj1_1.uvproj, settings and files
target Target_1 (MCS-51)
  device: C501 Infineon
  cpu: IRAM(0-0xFF)  CLOCK(40000000)
  output: Lab1Proj1_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab1part1_1.a51
